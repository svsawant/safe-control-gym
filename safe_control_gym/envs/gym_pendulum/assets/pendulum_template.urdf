Commit message: debug angle wrapping in cost

File: safe_control_gym/envs/gym_pendulum/assets/pendulum_template.urdf (robot description, URDF)
Before this commit: robot physics, 2 links, 1 joints
Links:
- link cart: mass 1 -> 0
